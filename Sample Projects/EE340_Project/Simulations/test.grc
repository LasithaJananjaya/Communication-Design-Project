options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: code1
  id: variable
  parameters:
    value: '''010110011011101100010101011111101001001110001011010001101010001'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blks2_packet_decoder_0
  id: blks2_packet_decoder
  parameters:
    access_code: code1
    threshold: '-1'
    type: byte
  states: {}
- name: blks2_packet_encoder_0
  id: blks2_packet_encoder
  parameters:
    access_code: code1
    bits_per_symbol: '1'
    pad_for_usrp: 'False'
    payload_length: '5'
    preamble: ''
    samples_per_symbol: '1'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/sudhir/Desktop/EE340_Project/output.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\Semester 3\EN2130 - Communication Design Project\Project\Test Flow Diagrams\Textfile1.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}

connections:
- [blks2_packet_decoder_0, '0', blocks_file_sink_0, '0']
- [blks2_packet_encoder_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blks2_packet_decoder_0, '0']
- [blocks_throttle_0, '0', blks2_packet_encoder_0, '0']

metadata:
  file_format: 1
