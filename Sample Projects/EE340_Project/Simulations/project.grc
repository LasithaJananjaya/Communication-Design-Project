options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: cma_gain
  id: variable_qtgui_range
  parameters:
    label: CMA
    orient: Qt.Horizontal
    start: '0'
    step: '1e-3'
    stop: '100e-3'
    value: '10e-3'
  states: {}
- name: costas_bw
  id: variable_qtgui_range
  parameters:
    label: Costas
    orient: Qt.Horizontal
    start: '0'
    step: '10e-3'
    stop: '1'
    value: '62.8e-3'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '350e-3'
  states: {}
- name: freq_off
  id: variable_qtgui_range
  parameters:
    label: Channel:Frequency offset
    orient: Qt.Horizontal
    start: '-100e-3'
    step: '1e-3'
    stop: '100e-3'
    value: '0'
  states: {}
- name: loop_bw
  id: variable_qtgui_range
  parameters:
    label: Time:BW
    orient: Qt.Horizontal
    start: '0'
    step: '10e-3'
    stop: '200e-3'
    value: '62.8e-3'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: channel:Noise Voltage
    orient: Qt.Horizontal
    start: '0'
    step: '10e-3'
    stop: '1'
    value: '100e-6'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: 11*nfilts*sps
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,nfilts,1.0,excess_bw,ntaps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_off
  id: variable_qtgui_range
  parameters:
    label: Channel:Timing Offset
    orient: Qt.Horizontal
    start: '999e-3'
    step: '100e-6'
    stop: '1.001'
    value: '1'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: D:\Semester 3\EN2130 - Communication Design Project\Project\Test Flow Diagrams\ReceivedText.txt
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\Semester 3\EN2130 - Communication Design Project\Project\Test Flow Diagrams\Textfile1.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '8'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: channel
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'qtgui_tab_widget_1@0 : 0,0'
    size: '1024'
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_off
    freq_offset: freq_off
    noise_voltage: noise_volt
    seed: '0'
    taps: '1.0 '
  states: {}
- name: clock
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'qtgui_tab_widget_1@1 : 0,0'
    size: '1024'
    type: complex
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: cma_gain
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: costas_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: '4'
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: '4'
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '2'
    timing_bw: 6.28/100.0
  states: {}
- name: equilizer
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'qtgui_tab_widget_1@2 : 0,0'
    size: '1024'
    type: complex
  states: {}
- name: equilizer_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'qtgui_tab_widget_1@3 : 0,0'
    size: '1024'
    type: complex
  states: {}
- name: output
  id: qtgui_time_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_1@4
    label1: ''
    size: '500'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'qtgui_tab_widget_1@2 : 0,1'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'qtgui_tab_widget_1@3 : 0,1'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'qtgui_tab_widget_1@0 : 0,1'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'qtgui_tab_widget_1@1 : 0,1'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_tab_widget_1
  id: qtgui_tab_widget
  parameters:
    label0: channel
    label1: clock
    label2: equilizer
    label3: frequency correction
    label4: difference
    num_tabs: '5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [blocks_char_to_float_0, '0', blocks_sub_xx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_0_0, '0', blocks_delay_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [blocks_file_source_0, '0', digital_constellation_modulator_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_sub_xx_0, '0', blocks_throttle_0_0_1, '0']
- [blocks_throttle_0_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_throttle_0_0_1, '0', output, '0']
- [blocks_throttle_1, '0', channels_channel_model_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_file_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_throttle_0_0_0, '0']
- [channels_channel_model_0, '0', channel, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_cma_equalizer_cc_0, '0', equilizer, '0']
- [digital_cma_equalizer_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_1, '0']
- [digital_costas_loop_cc_0, '0', digital_psk_demod_0, '0']
- [digital_costas_loop_cc_0, '0', equilizer_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', clock, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_freq_sink_x_2, '0']
- [digital_psk_demod_0, '0', digital_map_bb_0, '0']

metadata:
  file_format: 1
