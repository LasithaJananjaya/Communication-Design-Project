options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: BPSK
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    precision: '8'
    sym_map: '[0, 1]'
    type: bpsk
  states: {}
- name: baseband_LO
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: code1
  id: variable
  parameters:
    value: '''010110011011101100010101011111101001001110001011010001101010001'''
  states: {}
- name: code2
  id: variable
  parameters:
    value: '''11011010110111011000110011110101100010010011110111'''
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '25'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: rtl_samp_rate
  id: variable
  parameters:
    value: 1.024e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '102400'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '15'
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1024'
    reference: '1.55'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    freq: baseband_LO
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '-baseband_LO'
    offset: '0'
    phase: '0'
    samp_rate: rtl_samp_rate/10
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blks2_packet_decoder_0
  id: blks2_packet_decoder
  parameters:
    access_code: ''
    threshold: '-1'
    type: byte
  states: {}
- name: blks2_packet_encoder_0_0
  id: blks2_packet_encoder
  parameters:
    access_code: ''
    bits_per_symbol: '1'
    pad_for_usrp: 'False'
    payload_length: '0'
    preamble: '0101010101010101010101010101010101010101010101010101010101010'
    samples_per_symbol: '1'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\nucle\Desktop\out.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: F:\GNURadio\projects\annual-enterprise-survey-2018-financial-year-provisional-size-bands-csv.csv
    maxoutbuf: '500000'
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.0628'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_lms_dd_equalizer_cc_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: BPSK
    mu: '.01'
    num_taps: '8'
    sps: '1'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '.062'
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 10e6
    channel_mode: '0'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '60'
    gain_dB_ch1: '30'
    oversample: '1'
    pa_path_ch1: '1'
    rf_freq: 435e6
    samp_rate: rtl_samp_rate*2
    serial: 1D3ACA460218CE
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1.6E3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '20'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    clock_source0: internal
    dc_offset_mode0: '2'
    freq0: 435e6
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: rtl_samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_feedforward_agc_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blks2_packet_decoder_0, '0', blocks_char_to_float_0, '0']
- [blks2_packet_decoder_0, '0', blocks_file_sink_0, '0']
- [blks2_packet_encoder_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blks2_packet_encoder_0_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blks2_packet_decoder_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_xx_0, '0']
- [digital_costas_loop_cc_0, '0', digital_lms_dd_equalizer_cc_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', qtgui_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [low_pass_filter_0, '0', analog_feedforward_agc_cc_0, '0']
- [rational_resampler_xxx_0, '0', limesdr_sink_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_xx_0_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_1, '0']

metadata:
  file_format: 1
