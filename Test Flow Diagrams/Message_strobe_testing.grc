options:
  parameters:
    author: lenovo
    generate_options: qt_gui
    id: Message_strobe_testing
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("Demo")
    period: '1000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    timeout: '100'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, zeromq_pub_msg_sink_0, in]
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [zeromq_sub_msg_source_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
