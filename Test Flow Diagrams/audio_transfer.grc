options:
  parameters:
    author: lenovo
    generate_options: qt_gui
    id: audio_transfer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\lenovo\Desktop\audio\sending voice.wav
    repeat: 'True'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
